## app/dts/bindings/behaviors/zmk,behavior-mouse-jiggler.yaml
```yaml
description: Mouse jiggler behavior

compatible: "zmk,behavior-mouse-jiggler"

include: zero_param.yaml
```
